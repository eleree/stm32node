# Keil uVision project stm32node.uvprojx, settings and files
target stm32node (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32node
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,USE_HAL_DRIVER,STM32F407xx,LUA_CROSS_COMPILER,BUILD_FATFS
  c include: ../Inc;../Middlewares/Third_Party/LwIP/src/include;../Middlewares/Third_Party/LwIP/system;../Middlewares/Third_Party/mbedTLS/include;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/LwIP/src/include/netif/ppp;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/LwIP/src/include/lwip;../Middlewares/Third_Party/LwIP/src/include/lwip/apps;../Middlewares/Third_Party/LwIP/src/include/lwip/priv;../Middlewares/Third_Party/LwIP/src/include/lwip/prot;../Middlewares/Third_Party/LwIP/src/include/netif;../Middlewares/Third_Party/LwIP/src/include/posix;../Middlewares/Third_Party/LwIP/src/include/posix/sys;../Middlewares/Third_Party/LwIP/system/arch;../Middlewares/Third_Party/mbedTLS/include/mbedtls;../Drivers/CMSIS/Include;..\..\..\app\include;..\..\..\app\libc;..\..\..\app\lua;..\..\..\app\platform
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/AUDIO/Src/: usbd_audio.c
  group Lua/Cross
    ../../../app/lua/luac_cross/: lhal.c loslib.c luac.c print.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: queue.c tasks.c timers.c event_groups.c list.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: pbuf.c tcp_out.c mem.c def.c inet_chksum.c init.c netif.c stats.c udp.c sys.c ip.c tcp.c tcp_in.c raw.c timeouts.c dns.c memp.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: ipv6cp.c magic.c ccp.c pppcrypt.c mppe.c upap.c ipcp.c multilink.c chap-md5.c ppp.c lcp.c eap.c pppapi.c eui64.c vj.c chap_ms.c fsm.c pppol2tp.c auth.c chap-new.c pppoe.c pppos.c demand.c utils.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c slipif.c ethernet.c
    ../Middlewares/Third_Party/LwIP/src/api/: netbuf.c netifapi.c netdb.c api_msg.c api_lib.c sockets.c tcpip.c err.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: inet6.c nd6.c ethip6.c mld6.c ip6_frag.c ip6.c icmp6.c ip6_addr.c dhcp6.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_frag.c ip4_addr.c autoip.c icmp.c ip4.c etharp.c igmp.c dhcp.c
    ../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_cortex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c stm32f4xx_hal_gpio.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_dma.c stm32f4xx_hal_i2s.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_sd.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_eth.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_dac_ex.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/mbedTLS
    ../Middlewares/Third_Party/mbedTLS/library/: ssl_ciphersuites.c timing.c ssl_cookie.c memory_buffer_alloc.c x509_crt.c blowfish.c sha256.c camellia.c entropy.c dhm.c x509_csr.c oid.c x509_crl.c base64.c asn1parse.c cipher.c md.c version_features.c ecdsa.c x509.c ecp.c havege.c debug.c hmac_drbg.c pem.c gcm.c pkparse.c pk.c ssl_srv.c sha512.c ssl_tls.c aes.c cmac.c entropy_poll.c rsa.c x509write_csr.c md4.c md2.c ssl_cli.c md5.c ccm.c pkcs11.c ecjpake.c pkcs12.c pkwrite.c ecp_curves.c sha1.c x509write_crt.c des.c pkcs5.c certs.c ripemd160.c pk_wrap.c platform.c ssl_cache.c version.c cipher_wrap.c padlock.c ecdh.c ssl_ticket.c aesni.c bignum.c threading.c md_wrap.c x509_create.c arc4.c xtea.c error.c asn1write.c ctr_drbg.c
  group Application/User
    ../Src/: sd_diskio.c freertos.c usbd_audio_if.c stm32f4xx_hal_timebase_TIM.c stm32f4xx_hal_msp.c lwip.c usbd_conf.c ethernetif.c main.c usbd_desc.c net_sockets.c fatfs.c bsp_driver_sd.c mbedtls.c stm32f4xx_it.c usb_device.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Lua/Libc
    ../../../app/libc/: c_stdlib.c dbg_printf.c
  group Lua/Src
    ../../../app/lua/: lapi.c lauxlib.c lbaselib.c lcode.c ldblib.c ldebug.c ldo.c ldump.c legc.c lfunc.c lgc.c linit.c liolib.c llex.c lmathlib.c lmem.c loadlib.c lobject.c lopcodes.c lparser.c lrotable.c lstate.c lstring.c lstrlib.c ltable.c ltablib.c ltm.c lua.c lundump.c lvm.c lzio.c
  group App/FatFs
    ../../../app/fatfs/: myfatfs.c
  group App/Platform
    ../../../app/platform/: vfs.c
  group Lua/Hal
    ../../../app/hal/: osapi.c
software components: CMSIS:CORE 4.3.0
